# Keil uVision project RPMSG_TTY_CMSIS-RTOS2_M4.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MCIMX7D7:Cortex-M4 NXP
  pack: Keil.iMX7D_DFP.1.7.8
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x1FFF0000,0x00008000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: RPMSG_TTY_CMSIS-RTOS2_M4
  AfterMake: $K/ARM/ARMCC/bin/fromelf.exe --bincombined --output=$L@L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff0000 size 0x8000
  group Source Group 1
    ../DS-MDK/: tty_rtx.c
    ./: hardware_init.c
software components: AMP:RPMSG 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:OS Interface:Custom 2.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS-Compiler:TTY:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:HW INIT 1.0.0, Board Support:User I/O Redirect 1.0.0, Device:Startup 1.0.0, Device:iMX7D HAL:CCM 1.0.0, Device:iMX7D HAL:GPIO 1.0.0, Device:iMX7D HAL:MU 1.0.0, Device:iMX7D HAL:RDC 1.0.0, Device:iMX7D HAL:UART 1.0.0
